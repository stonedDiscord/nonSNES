# Repository stonedDiscord/nonSNES

File README.md:

# nonSNES
An Open-Source HardWare (OSHW) recreation of the Super Nintendo Entertainment System (PAL)

The design tries to be a 1:1 recreation of the original SNSP-CPU-01 Rev5 and SNSP-CPU-1CHIP boards.

## Some of the planned changes and improvements
- [X] Replace the obsolete trimmer capcaitor with an in-stock one
- [X] Replace the reset button with a regular mechanical keyboard switch
- [X] Include an AV out connector board using mousebites
- [X] Replace the U11 regulator (the old mitsumi one had a nonstandard pinout for reset monitors)
- [X] Include controller port board
- [ ] Remove the CIC/swap it for a CIC replacement
- [ ] Region switch
- [ ] Replace the audio RAM
- [ ] Replace the S-CLK clock generator
- [ ] ~~Include RGB bypass mod~~

## Tips if you decide to make this/get it made
The dimensions are 188x159mm.

If you decide to get it assembled I suggest only getting the bottom side with all the SMD components done and doing the top yourself.
The bottom only has jellybean capacitors, resistors, diodes, transistors so it's not going to be very expensive.

For the top you will have to salvage the Nintendo components. The video RAM is still being made by S@Tech (HM62256).
The audio RAM can probably also be easily replaced, I haven't looked into this yet. Feel free to open an issue about it.

## Roadmap:
See the checklist

## Inspired by
https://github.com/Redherring32/OpenTendo

## Other Projects
NTSC Versions: [OpenSFC](https://github.com/starlightk7/OpenSFC)

## Credits
ArcadeTV for the stripped scans:
https://circuit-board.de/forum/index.php/Thread/13913-STRIP-CLUB-PCB-Scans/

arzi84 for the schematic

## KiCad design SNSP-CPU-1CHIP/SNSP-CPU-1CHIP.kicad_pcb

Parts:
C1, C3, C6, C7, C8, C10, C11, C20, C21, C23, C24, C25, C26, C27, C28, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C58, C68, C70, C73, C74: ?; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: ?; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; not fitted
C4, C5, C29, C32, C33, C57, C62, C63, C64, C65, C66, C69: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 2.2uF 50V; CP_Elec_4x3
C12, C13: 10uF 16V; CP_Elec_4x3
C14, C16, C17: 33uF 25V; CP_Elec_6.3x5.4
C15: 47uF 16V; CP_Elec_6.3x5.4
C18, C19: 220uF 6V3; CP_Radial_Tantal_D4.5mm_P5.00mm
C22, C35, C36, C37, C38, C39, C40, C41, C42, C43: 330pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C30, C31: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C34, C60: 100uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C59: 10uF 25V; CP_Elec_6.3x5.4
C61: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C67: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C71: 10uF 50V; C_Elec_6.3x5.4
C72: 2200uF 25V; CP_Radial_D12.5mm_P5.00mm
C78: OS-CON; CP_Radial_Tantal_D4.5mm_P5.00mm
D1: 12V Zener; SC-59
D2, D3, D4, D5: A3; D_T-1_P5.08mm_Horizontal
DA1, DA2, DA3, DA4, DA5, DA12, DA14: DAP202; SC-59
DA6, DA7, DA8, DA9, DA10, DA11, DA15: DAN202; SC-59
DA13: DAN217; SC-59
F1: 1.5A; Fuse
FID1, FID2: Fiducial; Fiducial_0.75mm_Mask2.25mm
H1, H2, H3, H5, H6, H7, H10, H11: MountingHole; MountingHole_3.7mm
H4, H8, H9: MountingHole; MountingHole_3.7mm_Pad
H12, H13, H14, H15: MountingHole; MountingHole_2.2mm_M2
J1: Jack-DC; DcJack
L1, L2, L3, L4: ?; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
P1: CASSETTE
P2: JST 11FE-BT-VK-N; JST_ZE_Controllers
P3: PWR_SW; PinHeader_1x02_P2.00mm_Vertical
P4: AVOUT; AVOut
P5: EXPANSION
Q1, Q2, Q3: C2412; SC-59
R1, R49, R50, R52, R53: 200; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R12: 0; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1k6; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: ?; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7, R8, R31: ?; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; not fitted
R9, R10, R11, R30, R39, R40, R41, R42, R43, R44, R47: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13, R14, R23, R26, R28: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16, R17, R18, R19, R20: 39; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21: 470k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R22, R25, R29, R32, R33, R34, R35, R36, R37, R38, R48, R51: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24, R27: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RF1: RF_MODULATOR; RFModulator
SW1: RESET; ResetSwitch
T1: TDK zjys-2; L_CommonModeChoke_TDK_ACM7060
TC1: ?; CP_Radial_Tantal_D4.5mm_P5.00mm
TP1: TestPoint; TestPoint_Pad_D1.0mm
TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP36, TP37, TP38, TP39, TP40, TP41, TP42, TP43, TP44, TP45, TP46: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm
U1: S-CPUN(5A122); PQFP-160_28x28mm_P0.65mm
U2: S-APU; PQFP-100_14x20mm_P0.65mm
U3: WRAM; SOP-64_11x28mm_P0,75mm
U4, U5: 32Kx8_SRAM; RAM
U6: UPD6379A; SO-8_3.9x4.9mm_P1.27mm
U7: S-RGB; SO-24_5.3x15mm_P1.27mm
U8: CIC; SOIC-18_7x12mm_P0,8mm
U9: L7805; TO-220-3_Vertical
U10: S-MIX; SO-14_3.9x8.65mm_P1.27mm
U11: T5290; SC-59_Handsoldering
VA1: ERZC050K220; RV_Disc_D7mm_W3.4mm_P5mm
X1: 17.734476MHz; Crystal_HC18-U_Vertical
X2: 24.57MHz; Crystal_HC49-U-3Pin_Vertical

Connections (part):
+5V: C4.1, C5.1, C9.1, C11.2, C29.1, C57.1, C58.1, C60.1, C61.1, C63.2, C64.2, C65.1, C66.1, C67.1, C68.1, C69.1, C78.1, DA6.3 (K), DA7.3 (K), DA8.3 (K), DA9.3 (K), DA10.3 (K), DA11.3 (K), DA15.3 (K), P1.27 (+5V), P1.58 (+5V), P2.1 (VCC), P4.10 (VCC), P5.20 (Vcc), Q1.3 (C), Q2.3 (C), Q3.3 (C), R13.1, R14.1, R29.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, RF1.1 (+5V), SW1.2, U1.10 (5V), U1.23 (5V), U1.49 (5V), U1.80 (5V), U1.101 (5V), U1.110 (5V), U1.111 (NTSC/PAL), U1.121 (5V), U1.155 (5V), U2.3 (5V), U2.28 (5V), U2.53 (5V), U2.71 (?), U2.78 (5V), U2.89 (?), U3.1 (VCC), U3.10 (CS1), U3.11 (CS2), U3.12 (CS3), U3.16 (VCC), U3.32 (VCC), U3.49 (VCC), U3.51 (PS2), U3.52 (PS3), U4.28 (VCC), U5.28 (VCC), U6.8 (VDD), U7.6 (+5V), U7.19 (+5V), U8.4 (P03), U8.18 (VCC), U9.3 (OUT), U11.2 (VDD)
/4016.D0: DA3.2 (K), DA8.2 (A), R37.2, R43.2, U1.77 (4016.D0)
/4016.D1: DA3.1 (K), DA8.1 (A), R38.2, R44.1, U1.76 (4016.D1)
/4017.D0: DA4.2 (K), DA9.2 (A), R36.2, R41.2, U1.82 (4017.D0)
/4017.D1: DA4.1 (K), DA9.1 (A), R35.2, R42.1, U1.83 (4017.D1)
/B: C8.2, R8.2, U1.158 (B)
/BFP: U1.152 (BFP), U7.8 (BFP)
/CA0: P1.17 (A0), U1.125 (CA0), U3.23 (A0)
/CA1: P1.16 (A1), U1.127 (CA1), U3.25 (A1)
/CA2: P1.15 (A2), U1.129 (CA2), U3.27 (A2)
/CA3: P1.14 (A3), U1.131 (CA3), U3.29 (A3)
/CA4: P1.13 (A4), U1.133 (CA4), U3.31 (A4)
/CA5: P1.12 (A5), U1.135 (CA5), U3.35 (A5)
/CA6: P1.11 (A6), U1.137 (CA6), U3.37 (A6)
/CA7: P1.10 (A7), U1.139 (CA7), U3.39 (A7)
/CA8: P1.9 (A8), U1.141 (CA8), U3.41 (A8)
/CA9: P1.8 (A9), U1.143 (CA9), U3.24 (A9)
/CA10: P1.7 (A10), U1.145 (CA10), U3.26 (A10)
/CA11: P1.6 (A11), U1.147 (CA11), U3.28 (A11)
/CA12: P1.37 (A12), U1.148 (CA12), U3.30 (A12)
/CA13: P1.38 (A13), U1.146 (CA13), U3.34 (A13)
/CA14: P1.39 (A14), U1.144 (CA14), U3.36 (A14)
/CA15: P1.40 (A15), U1.142 (CA15), U3.38 (A15)
/CA16: P1.41 (A16), U1.140 (CA16), U3.40 (A16)
/CA17: P1.42 (A17), U1.138 (CA17)
/CA18: P1.43 (A18), U1.136 (CA18)
/CA19: P1.44 (A19), U1.134 (CA19)
/CA20: P1.45 (A20), U1.132 (CA20)
/CA21: P1.46 (A21), U1.130 (CA21)
/CA22: P1.47 (A22), U1.128 (CA22), U3.42 (ENA)
/CA23: P1.48 (A23), U1.126 (CA23)
/CSYNC: U1.151 (CSYNC), U7.7 (CSYNC)
/D0: P1.19 (D0), P5.11 (D0), U1.94 (D0), U2.8 (D0), U3.60 (D0)
/D1: P1.20 (D1), P5.12 (D1), U1.92 (D1), U2.10 (D1), U3.61 (D1)
/D2: P1.21 (D2), P5.13 (D2), U1.90 (D2), U2.12 (D2), U3.62 (D2)
/D3: P1.22 (D3), P5.14 (D3), U1.88 (D3), U2.14 (D3), U3.63 (D3)
/D4: P1.50 (D4), P5.15 (D4), U1.95 (D4), U2.7 (D4), U3.2 (D4)
/D5: P1.51 (D5), P5.16 (D5), U1.93 (D5), U2.9 (D5), U3.3 (D5)
/D6: P1.52 (D6), P5.17 (D6), U1.91 (D6), U2.11 (D6), U3.4 (D6)
/D7: P1.53 (D7), P5.18 (D7), U1.89 (D7), U2.13 (D7), U3.5 (D7)
/FILTERED_SLEEVE: C31.2, D4.2 (A), D5.1 (K), T1.4
/FILTERED_TIP: C31.1, C59.2, D2.1 (K), D3.2 (A), T1.3
/FUSED: C32.1, F1.2, P3.1
/G: C7.2, R7.2, U1.157 (G)
/IN_SLEEVE: C30.1, J1.2, T1.1
/IN_TIP: C30.2, J1.1, T1.2
/JPCLK1: DA2.2 (K), DA7.2 (A), L2.2, U1.79 (JPCLK1)
/JPCLK2: DA2.1 (K), DA7.1 (A), L3.1, U1.81 (JPCLK2)
/JPIO6: DA5.2 (K), DA10.2 (A), R33.2, R39.2, U1.75 (JPIO6)
/JPIO7: DA5.1 (K), DA10.1 (A), R34.2, R40.1, U1.84 (JPIO7), U1.85 (JPIO7)
/JPSTR: DA1.2 (K), DA6.2 (A), R47.2, U1.78 (JPSTR)
/PA0: P1.28 (PA0), P5.1 (PA0), U1.102 (PA0), U2.18 (A0), U3.53 (PA0)
/PA1: P1.59 (PA1), P5.2 (PA1), U1.103 (PA1), U2.17 (A1), U3.54 (PA1)
/PA2: P1.29 (PA2), P5.3 (PA2), U1.104 (PA2), U3.43 (PS1)
/PA3: P1.60 (PA3), P5.4 (PA3), U1.105 (PA3), U3.44 (PS2)
/PA4: P1.30 (PA4), P5.5 (PA4), U1.106 (PA4), U3.45 (PS3)
/PA5: P1.61 (PA5), P5.6 (PA5), U1.107 (PA5), U3.46 (PS4)
/PA6: P1.3 (PA6), P5.7 (PA6), U1.108 (PA6), U2.2 (CS), U3.47 (PS5)
/PA7: P1.34 (PA7), P5.8 (PA7), U1.109 (PA7), U2.1 (~CS), U3.50 (PS1)
/R: C6.2, R6.2, U1.156 (R)
/RECTIFIED: C72.1, D3.1 (K), D4.1 (K), F1.1
/SC: C73.2, R4.2, U1.150 (SC)
/SWITCHED: C14.1, C33.1, C34.1, C62.2, DA13.1 (A), P3.2, U9.1 (IN), U10.1 (12V), VA1.1
/VA14: TP2.1 (1_1), U1.35 (VA14), U4.1 (A14), U5.1 (A14)
/VAA0: TP31.1 (1_1), U1.70 (VAA0), U5.10 (A0)
/VAA1: TP30.1 (1_1), U1.69 (VAA1), U5.9 (A1)
/VAA2: TP29.1 (1_1), U1.68 (VAA2), U5.8 (A2)
/VAA3: TP28.1 (1_1), U1.67 (VAA3), U5.7 (A3)
/VAA4: TP27.1 (1_1), U1.66 (VAA4), U5.6 (A4)
/VAA5: TP26.1 (1_1), U1.65 (VAA5), U5.5 (A5)
/VAA6: TP25.1 (1_1), U1.64 (VAA6), U5.4 (A6)
/VAA7: TP24.1 (1_1), U1.63 (VAA7), U5.3 (A7)
/VAA8: TP23.1 (1_1), U1.59 (VAA8), U5.25 (A8)
/VAA9: TP22.1 (1_1), U1.58 (VAA9), U5.24 (A9)
/VAA10: TP21.1 (1_1), U1.55 (VAA10), U5.21 (A10)
/VAA11: TP20.1 (1_1), U1.57 (VAA11), U5.23 (A11)
/VAA12: TP19.1 (1_1), U1.62 (VAA12), U5.2 (A12)
/VAA13: TP18.1 (1_1), U1.60 (VAA13), U5.26 (A13)
/VAB0: TP16.1 (1_1), U1.44 (VAB0), U4.10 (A0)
/VAB1: TP15.1 (1_1), U1.43 (VAB1), U4.9 (A1)
/VAB2: TP14.1 (1_1), U1.42 (VAB2), U4.8 (A2)
/VAB3: TP13.1 (1_1), U1.41 (VAB3), U4.7 (A3)
/VAB4: TP12.1 (1_1), U1.40 (VAB4), U4.6 (A4)
/VAB5: TP11.1 (1_1), U1.39 (VAB5), U4.5 (A5)
/VAB6: TP10.1 (1_1), U1.38 (VAB6), U4.4 (A6)
/VAB7: TP9.1 (1_1), U1.37 (VAB7), U4.3 (A7)
/VAB8: TP8.1 (1_1), U1.32 (VAB8), U4.25 (A8)
/VAB9: TP7.1 (1_1), U1.31 (VAB9), U4.24 (A9)
/VAB10: TP6.1 (1_1), U1.29 (VAB10), U4.21 (A10)
/VAB11: TP5.1 (1_1), U1.30 (VAB11), U4.23 (A11)
/VAB12: TP4.1 (1_1), U1.36 (VAB12), U4.2 (A12)
/VAB13: TP3.1 (1_1), U1.33 (VAB13), U4.26 (A13)
/VDA0: TP46.1 (1_1), U1.71 (VDA0), U5.11 (DQ0)
/VDA1: TP45.1 (1_1), U1.72 (VDA1), U5.12 (DQ1)
/VDA2: TP44.1 (1_1), U1.73 (VDA2), U5.13 (DQ2)
/VDA3: TP43.1 (1_1), U1.50 (VDA3), U5.15 (DQ3)
/VDA4: TP42.1 (1_1), U1.51 (VDA4), U5.16 (DQ4)
/VDA5: TP41.1 (1_1), U1.52 (VDA5), U5.17 (DQ5)
/VDA6: TP40.1 (1_1), U1.53 (VDA6), U5.18 (DQ6)
/VDA7: TP39.1 (1_1), U1.54 (VDA7), U5.19 (DQ7)
/VDB0: TP38.1 (1_1), U1.45 (VDB0), U4.11 (DQ0)
/VDB1: TP35.1 (1_1), U1.46 (VDB1), U4.12 (DQ1)
/VDB2: TP36.1 (1_1), U1.47 (VDB2), U4.13 (DQ2)
/VDB3: TP37.1 (1_1), U1.24 (VDB3), U4.15 (DQ3)
/VDB4: TP32.1 (1_1), U1.25 (VDB4), U4.16 (DQ4)
/VDB5: TP33.1 (1_1), U1.26 (VDB5), U4.17 (DQ5)
/VDB6: TP34.1 (1_1), U1.27 (VDB6), U4.18 (DQ6)
/VDB7: TP17.1 (1_1), U1.28 (VDB7), U4.19 (DQ7)
/~CPURD: P1.23 (RD), U1.115 (~CPURD), U3.57 (RD)
/~CPUWR: P1.54 (WR), U1.116 (~CPUWR), U3.59 (WR)
/~PARD: P1.4 (PARD), P5.10 (~PARD), U1.99 (~PARD), U2.6 (~RD), U3.56 (PARD)
/~PAWR: P1.35 (PAWR), P5.9 (~PAWR), U1.100 (~PAWR), U2.5 (~WR), U3.58 (PAWR)
/~RAMSEL: P1.32 (WRAMSEL), U1.96 (~RAMSEL), U3.15 (CS3)
/~ROMSEL: P1.49 (ROMSEL), U1.124 (~ROMSEL)
/~VAWR: U1.61 (~VAWR), U5.27 (~WE)
/~VBWR: U1.34 (~WBWR), U4.27 (~WE)
/~VRD: U1.56 (~VRD), U4.22 (~OE), U5.22 (~OE)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C10.2, C14.2, C15.2, C16.2, C17.2, C20.2, C21.2, C22.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C55.2, C56.2, C57.2, C58.2, C60.2, C61.2, C62.1, C63.1, C64.1, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.1, C74.2, C78.2, D1.1 (A), D2.2 (A), D5.2 (A), DA1.3 (A), DA2.3 (A), DA3.3 (A), DA4.3 (A), DA5.3 (A), DA12.3 (A), DA14.3 (A), H4.1 (1_1), H8.1 (1_1), H9.1 (1_1), P1.5 (GND), P1.36 (GND), P1.SHIELD (GND), P2.11 (GND), P4.5 (GND), P4.6 (GND), P5.23 (GND), R3.2, R5.2, R6.1, R7.1, R8.1, R9.2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
unnamed: C1.1, R1.2, TP1.1 (1_1)
unnamed: C2.2, R2.1, X1.2
unnamed: C11.1, U1.154 (?)
unnamed: C12.1, R26.1
unnamed: C13.1, R23.1
unnamed: C18.2, R18.2
unnamed: C19.2, R19.2
unnamed: C41.1, L1.2, L2.1
unnamed: C42.1, L3.2, L4.1
unnamed: C53.2, R4.1, R5.1
unnamed: C54.1, R20.2
unnamed: C71.1, DA13.2 (A), R28.2
unnamed: C46.1, D1.3 (K), P4.3 (CSYNC), R28.1
unnamed: C59.1, DA13.3 (K)
unnamed: P1.24 (CIC0), U8.2 (P01)
unnamed: P1.55 (CIC1), U8.1 (P00)
unnamed: P1.25 (CIC2), U8.11
unnamed: C20.1, P1.56 (CIC3), U1.118 (CIC3)
unnamed: P1.2 (EXPAND), P5.24 (EXPAND), R32.2
unnamed: P1.18 (IRQ), P5.26 (~IRQ), R29.2, U1.123 (~IRQ)
unnamed: C10.1, P1.1 (MCK_21M), R30.2, R31.1
unnamed: P1.33 (REFRESH), U1.97 (REFRESH), U3.7 (REFRESH)
unnamed: P1.26 (RESET), P5.19 (~RESET), R13.2, U1.86 (~RESET), U2.16 (~RESOUT1?), U3.8 (RESET), U11.1 (~RST)
unnamed: C28.2, P1.31 (SOUND-L), R53.2
unnamed: C25.2, P1.62 (SOUND-R), R50.2
unnamed: P1.57 (SYSCK), U1.120 (SYSCK), U3.6 (SYSCK)
unnamed: C39.1, P2.6 (4016.D0), R43.1
unnamed: C40.1, P2.7 (4016.D1), R44.2
unnamed: C37.1, P2.4 (4017.D0), R41.1
unnamed: C38.1, P2.5 (4017.D1), R42.2
unnamed: L1.1, P2.8 (JPCLK1)
unnamed: L4.2, P2.9 (JPCLK2)
unnamed: C35.1, P2.2 (JPIO6), R39.1
unnamed: C36.1, P2.3 (JPIO7), R40.2
unnamed: C43.1, P2.10 (JPSTR), R47.1
unnamed: C12.2, C51.1, P4.11 (Audio-L)
unnamed: C13.2, C52.1, P4.12 (Audio-R)
unnamed: C47.1, P4.4 (Blue), R17.1
unnamed: C49.1, P4.8 (C-SV), R20.1
unnamed: C50.1, P4.9 (CV), R18.1
unnamed: C45.1, P4.2 (Green), R16.1
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
Notes on the sheet:
AC9V1.3A for PAL
Change C11 to 470nF for ghosting fix
Change R3 to 1k74 for brightness fix
