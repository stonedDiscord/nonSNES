# Repository stonedDiscord/nonSNES (continued)

## KiCad design SNSP-CPU-1CHIP/SNSP-CPU-1CHIP.kicad_pcb (continued)

Board: 2 copper layers, 155.5 x 161.9 mm, 241 parts (182 on the bottom side), 212 nets.
