# Repository stonedDiscord/nonSNES (continued)

## KiCad design SNSP-CPU-01/SNSP-CPU-01.kicad_pcb (continued)

Board: 2 copper layers, 215.8 x 159.0 mm, 400 parts (339 on the bottom side), 363 nets.

## KiCad design nonSNES.kicad_pcb

Parts:
C29, C85: 0.1u; C_0805_2012Metric
C30: 0.01uF; C_0805_2012Metric
C31, C34, C95, C97: 0.1uF; C_0805_2012Metric
C35, C36, C37, C38, C39, C40, C41, C42, C43: 330p; C_0805_2012Metric
C62: 2.2u; C_0805_2012Metric
C63, C64: C_Polarized; CP_Elec_6.3x3
C67: 2200u; CP_Radial_D16.0mm_P7.50mm
C81: 1uF; C_0805_2012Metric
C92, C93, C94: C; C_0805_2012Metric
C107: 0.01u; C_0805_2012Metric
DA2, DA3, DA4, DA5, DA7, DA8, DA9, DA10: D; SOT-23
DB1: D_Bridge_+AA-; FullBridgeRectifier
F1: Fuse
J1: Jack-DC; DcJack
J2: RFModulator
P1: CASSETTE
P2: Conn_2Rows-11Pins; JST_ZE_Controllers
P3: Conn_01x02_Male; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
P4: AVOut
R78, R80, R82: 10k; R_0805_2012Metric
R83, R84, R85, R86, R87, R88, R89, R90, R91: 100; R_0805_2012Metric
SW1: RESET SW; SW_MEC_5GTH9
T1: L_Coupled; L_CommonMode_Delevan_4222
U1: CPU; PQFP-100_14x20mm_P0.65mm
U2: PPU1; PQFP-100_14x20mm_P0.65mm
U3: PPU2; PQFP-100_14x20mm_P0.65mm
U4, U5, U15, U16: MS62256CL-10FC; SOIC-28W_7.5x17.9mm_P1.27mm
U6: WRAM; TSSOP-64_6.1x17mm_P0.5mm
U7: SO-24_5.3x15mm_P1.27mm
U8: CIC; SSOP-18_4.4x6.5mm_P0.65mm
U10: LM324; SO-14_3.9x8.65mm_P1.27mm
U12: L7805; TO-220-3_Vertical
U13: S-SMP; LQFP-64_14x14mm_P0.8mm
U14: PQFP-80_14x20mm_P0.8mm
VA1: Varistor; D_3220_8050Metric
X1: Crystal; Crystal_HC49-4H_Vertical

Connections:
/CA0: P1.17 (A0), U1.93 (A0), U6.23 (A0)
/CA1: P1.16 (A1), U1.94 (A1), U6.25 (A1)
/CA2: P1.15 (A2), U1.95 (A2), U6.27 (A2)
/CA3: P1.14 (A3), U1.96 (A3), U6.29 (A3)
/CA4: P1.13 (A4), U1.97 (A4), U6.31 (A4)
/CA5: P1.12 (A5), U1.98 (A5), U6.35 (A5)
/CA6: P1.11 (A6), U1.99 (A6), U6.37 (A6)
/CA7: P1.10 (A7), U1.100 (A7), U6.39 (A7)
/CA8: P1.9 (A8), U1.2 (A8), U6.41 (A8)
/CA9: P1.8 (A9), U1.3 (A9), U6.24 (A9)
/CA10: P1.7 (A10), U1.4 (A10), U6.26 (A10)
/CA11: P1.6 (A11), U1.5 (A11), U6.28 (A11)
/CA12: P1.37 (A12), U1.6 (A12), U6.30 (A12)
/CA13: P1.38 (A13), U1.7 (A13), U6.34 (A13)
/CA14: P1.39 (A14), U1.8 (A14), U6.36 (A14)
/CA15: P1.40 (A15), U1.9 (A15), U6.38 (A15)
/CA16: P1.41 (A16), U1.10 (A16), U6.40 (A16)
/CA17: P1.42 (A17), U1.11 (A17)
/CA18: P1.43 (A18), U1.12 (A18)
/CA19: P1.44 (A19), U1.13 (A19)
/CA20: P1.45 (A20), U1.14 (A20)
/CA21: P1.46 (A21), U1.15 (A21)
/CA22: P1.47 (A22), U1.16 (A22)
/CA23: P1.48 (A23), U1.17 (A23)
/D0: P1.19 (D0), U1.60 (D0), U2.21 (D0), U3.15 (D0), U6.60 (D0)
/D1: P1.20 (D1), U1.61 (D1), U2.20 (D1), U3.14 (D1), U6.61 (D1)
/D2: P1.21 (D2), U1.62 (D2), U2.19 (D2), U3.13 (D2), U6.62 (D2)
/D3: P1.22 (D3), U1.63 (D3), U2.18 (D3), U3.12 (D3), U6.63 (D3)
/D4: P1.50 (D4), U1.64 (D4), U2.17 (D4), U3.11 (D4), U6.2 (D4)
/D5: P1.51 (D5), U1.65 (D5), U2.16 (D5), U3.10 (D5), U6.3 (D5)
/D6: P1.52 (D6), U1.66 (D6), U2.15 (D6), U3.9 (D6), U6.4 (D6)
/D7: P1.53 (D7), U1.67 (D7), U2.14 (D7), U3.8 (D7), U6.5 (D7)
/VA14: U2.47 (VA14), U4.1 (A14), U5.1 (A14)
/VAA0: U2.76 (VAA0), U5.10 (A0)
/VAA1: U2.75 (VAA1), U5.9 (A1)
/VAA2: U2.74 (VAA2), U5.8 (A2)
/VAA3: U2.73 (VAA3), U5.7 (A3)
/VAA4: U2.72 (VAA4), U5.6 (A4)
/VAA5: U2.71 (VAA5), U5.5 (A5)
/VAA6: U2.70 (VAA6), U5.4 (A6)
/VAA7: U2.69 (VAA7), U5.3 (A7)
/VAA8: U2.68 (VAA8), U5.25 (A8)
/VAA9: U2.67 (VAA9), U5.24 (A9)
/VAA10: U2.66 (VAA10), U5.21 (A10)
/VAA11: U2.65 (VAA11), U5.23 (A11)
/VAA12: U2.64 (VAA12), U5.2 (A12)
/VAA13: U2.63 (VAA13), U5.26 (A13)
/VAB0: U2.61 (VAB0), U4.10 (A0)
/VAB1: U2.60 (VAB1), U4.9 (A1)
/VAB2: U2.59 (VAB2), U4.8 (A2)
/VAB3: U2.58 (VAB3), U4.7 (A3)
/VAB4: U2.57 (VAB4), U4.6 (A4)
/VAB5: U2.56 (VAB5), U4.5 (A5)
/VAB6: U2.55 (VAB6), U4.4 (A6)
/VAB7: U2.54 (VAB7), U4.3 (A7)
/VAB8: U2.53 (VAB8), U4.25 (A8)
/VAB9: U2.52 (VAB9), U4.24 (A9)
/VAB10: U2.51 (VAB10), U4.21 (A10)
/VAB11: U2.50 (VAB11), U4.23 (A11)
/VAB12: U2.49 (VAB12), U4.2 (A12)
/VAB13: U2.48 (VAB13), U4.26 (A13)
/VDA0: U2.37 (VDA0), U3.60 (VDA0), U5.11 (Q0)
/VDA1: U2.38 (VDA1), U3.61 (VDA1), U5.12 (Q1)
/VDA2: U2.39 (VDA2), U3.62 (VDA2), U5.13 (Q2)
/VDA3: U2.40 (VDA3), U3.63 (VDA3), U5.15 (Q3)
/VDA4: U2.41 (VDA4), U3.64 (VDA4), U5.16 (Q4)
/VDA5: U2.42 (VDA5), U3.65 (VDA5), U5.17 (Q5)
/VDA6: U2.43 (VDA6), U3.66 (VDA6), U5.18 (Q6)
/VDA7: U2.44 (VDA7), U3.67 (VDA7), U5.19 (Q7)
/VDB0: U2.28 (VDB0), U3.51 (VDB0), U3.69 (EXT0), U4.11 (Q0)
/VDB1: U2.29 (VDB1), U3.52 (VDB1), U3.70 (EXT1), U4.12 (Q1)
/VDB2: U2.30 (VDB2), U3.53 (VDB2), U3.71 (EXT2), U4.13 (Q2)
/VDB3: U2.31 (VDB3), U3.54 (VDB3), U3.72 (EXT3), U4.15 (Q3)
/VDB4: U2.32 (VDB4), U3.55 (VDB4), U3.73 (EXT4), U4.16 (Q4)
/VDB5: U2.33 (VDB5), U3.56 (VDB5), U3.74 (EXT5), U4.17 (Q5)
/VDB6: U2.34 (VDB6), U3.57 (VDB6), U3.75 (EXT6), U4.18 (Q6)
/VDB7: U2.35 (VDB7), U3.58 (VDB7), U3.76 (EXT7), U4.19 (Q7)
GND: C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C85.2, C107.2, DA2.2 (A), DA3.2 (A), DA4.2 (A), DA5.2 (A), J2.4 (GND), P1.SHIELD (GND), P2.11, P4.5 (GND), P4.6 (GND), U1.18 (GND), U1.47 (GND), U1.79 (GND), U1.90 (GND), U2.22 (GND), U2.45 (GND), U2.77 (GND), U2.96 (GND), U3.16 (GND), U3.30 (PALMODE), U3.35 (GND), U3.68 (GND), U3.90 (TST12), U3.91 (TST13), U3.92 (TST14), U3.93 (TST15), U3.99 (GND), U6.17 (GND), U6.33 (GND), U6.48 (GND), U6.64 (GND), U8.9 (GND)
GNDPWR: C34.2, C81.2, C92.2, C93.2, C94.2, C95.2, C97.2, DB1.4 (-), U4.14 (GND), U4.20 (~CS), U5.14 (GND), U5.20 (~CS), U12.2 (GND)
unnamed: C30.1, J1.2, T1.2
unnamed: C30.2, J1.1, T1.1
unnamed: C31.1, DB1.2, T1.4
unnamed: C31.2, DB1.3, T1.3
unnamed: DA2.1 (K), DA7.2 (A), R90.2
unnamed: DA3.1 (K), DA8.2 (A), R82.2, R88.2
unnamed: DA4.1 (K), DA9.2 (A), R80.2, R86.2
unnamed: DA5.1 (K), DA10.2 (A), R78.2, R84.2
unnamed: DB1.1 (+), F1.1
unnamed: C35.1, P2.2, R83.1
unnamed: C36.1, P2.3, R84.1
unnamed: C37.1, P2.4, R85.1
unnamed: C38.1, P2.5, R86.1
unnamed: C39.1, P2.6, R87.1
unnamed: C40.1, P2.7, R88.1
unnamed: C41.1, P2.8, R89.1
unnamed: C42.1, P2.9, R90.1
unnamed: C43.1, P2.10, R91.1
unnamed: C34.1, P3.1, U12.1 (IN)
unnamed: F1.2, P3.2
unnamed: C62.2, U8.3 (P02)
unnamed: C29.2, SW1.1, U8.8 (RES)
unnamed: U13.5 (CPUA0), U14.60 (A0)
unnamed: U13.4 (CPUA1), U14.61 (A1)
unnamed: U13.3 (CPUA2), U14.62 (A2)
unnamed: U13.2 (CPUA3), U14.63 (A3)
unnamed: U13.1 (CPUA4), U14.64 (A4)
unnamed: U13.64 (CPUA5), U14.65 (A5)
unnamed: U13.63 (CPUA6), U14.66 (A6)
unnamed: U13.62 (CPUA7), U14.67 (A7)
unnamed: U13.61 (CPUA8), U14.68 (A8)
unnamed: U13.60 (CPUA9), U14.69 (A9)
unnamed: U13.59 (CPUA10), U14.70 (A10)
unnamed: U13.56 (CPUA11), U14.71 (A11)
unnamed: U13.55 (CPUA12), U14.72 (A12)
unnamed: U13.54 (CPUA13), U14.74 (A13)
unnamed: U13.53 (CPUA14), U14.75 (A14)
unnamed: U13.52 (CPUA15), U14.76 (A15)
unnamed: U13.13 (CPUD0), U14.51 (D0)
unnamed: U13.12 (CPUD1), U14.53 (D1)
unnamed: U13.11 (CPUD2), U14.54 (D2)
unnamed: U13.10 (CPUD3), U14.55 (D3)
unnamed: U13.9 (CPUD4), U14.56 (D4)
unnamed: U13.8 (CPUD5), U14.57 (D5)
unnamed: U13.7 (CPUD6), U14.58 (D6)
unnamed: U13.6 (CPUD7), U14.59 (D7)
unnamed: U13.16 (CPUK), U14.48 (CPUK)
unnamed: U13.15 (PD2), U14.49 (PD2)
unnamed: U13.14 (PD3), U14.50 (PD3)
VCC: C29.1, C62.1, C81.1, C85.1, C92.1, C93.1, C94.1, C95.1, C97.1, C107.1, DA7.1 (K), DA8.1 (K), DA9.1 (K), DA10.1 (K), P2.1, R78.1, R80.1, R82.1, SW1.2, U1.1 (VCC), U1.34 (VCC), U1.59 (VCC), U1.85 (VCC), U2.13 (VCC), U2.36 (VCC), U2.62 (VCC), U2.81 (VCC), U3.5 (VCC), U3.32 (VCC), U3.59 (VCC), U3.83 (VCC), U3.94 (AVCC), U4.28 (VCC), U5.28 (VCC), U6.1 (VCC), U6.16 (VCC), U6.32 (VCC), U6.49 (VCC), U8.4 (P03), U8.18 (VCC), U12.3 (OUT)

Board: 2 copper layers, 188.0 x 158.8 mm, 71 parts (42 on the bottom side), 129 nets.

## Commit log

2023-01-24 dc jack
2023-01-24 rectifies outline
2023-01-24 add ram and voltage reg
2023-01-24 replace footprints
2023-01-24 connect vram data lines
2023-02-07 get board outline right
2023-02-08 add ppu
2023-02-08 fix misaligned pins
2023-02-08 add caps for ppu
2023-02-08 fix ram package
2023-02-08 place ppu
2023-03-16 add WRAM
2023-03-16 GND is not inverted on the CPU
2023-03-16 add crystal
2023-03-16 update project version
2023-07-24 add controller port
2023-07-24 keep gerber folder
2023-07-24 oh damn
2023-07-24 with
2023-07-24 kicad exports is deprecated
2023-07-24 spelling mistake
2023-07-24 no erc
2023-07-24 we use ki7
2023-07-24 erc fails
2023-07-24 use local dir
2023-07-24 specify filenames
2023-07-24 add drill files
2023-07-24 fucked the intendation again
2023-07-24 wrong format
2023-07-24 im compare
2023-07-24 kibot drawing
2023-07-24 don't create gerbers that can't be produced
2023-07-24 bottom png
2023-07-24 smaller original
2023-07-24 other side
2023-07-24 IM bug from 2013
    https://www.imagemagick.org/discourse-server/viewtopic.php?t=23722
2023-07-24 colors
2023-07-24 switch to jpg
2023-07-24 use magick compose
2023-07-24 Squashed commit of the following:
    commit 3bde77f0be38bd533f7311f6b1c9aa75bd53250c
    Author: stonedDiscord <Tukz@gmx.de>
    Date: Tue Jul 25 01:27:26 2023 +0200
    use magick compose
    commit 4b2a870971239963e521527992fc19ab04bbc71e
    Author: stonedDiscord <Tukz@gmx.de>
2023-07-24 add fills
2023-07-24 more copper
2023-07-24 back end
2023-07-25 fix drc
2023-07-25 fix mask area
2023-07-25 masks
2023-07-25 bottom copper fill
2023-07-25 longer thinner dc jack holes
2023-07-25 cartridge slot
2023-07-25 add cic and wram to board
2023-07-25 rename cic
2023-07-25 cartridge port again
2023-07-25 sanded pcb
2023-07-25 move cartridge and fix mask
2023-07-25 drc error?
2023-07-25 wire cic and reset sw
2023-07-25 vias, sw
2023-07-25 connector
2023-07-25 move caps around again
2023-07-25 pad and cap
2023-07-25 vias
2023-07-25 copper fill and vias
2023-07-25 bottom ground
2023-07-25 pad caps
2023-07-25 pad traces and keepout
2023-07-25 get rid of drc errors
2023-07-25 flood
2023-07-25 bottom pour
2023-07-25 sssssssss
2023-07-25 cap footprint and crystal footprint
2023-07-25 silkscreen
2023-07-25 cartridge port
2023-07-25 avout and rfmod
2023-07-25 they are bigger in rl
2023-07-25 this is fucked
2023-07-25 rfmod and av
2023-07-25 pins right?
2023-07-25 lines av rf
2023-08-16 s-enc
2023-08-16 sound
2023-08-17 shapes
2023-11-27 import image
2023-11-30 footprints
2023-11-30 more stuff
2023-12-01 sdftghdrfhs
2023-12-05 new footprint
2023-12-08 dfgdfghdr
2023-12-20 reset
2024-01-10 grounds
2024-01-11 done!!!!!!!!!
2024-01-18 manufacturing data
2024-01-30 values
2024-01-31 references
2024-01-31 upload scan of repro
2024-01-31 footprint silkscreen
2024-01-31 update board
2024-01-31 fix 100nF
2024-01-31 fix errors
2024-01-31 flip around most of the silkscreen on the bottom
2024-01-31 mark DNP components
2024-02-02 add testpoints
2024-02-06 DNP rectangles
2024-02-06 these resistors are 10 ohms not 100
2024-02-07 fix S-Video
2024-02-07 more testpoints
2024-02-09 one more dnp border
2024-02-16 add my sob story and av out
2024-02-28 remove bg images to fix lag
2024-02-28 use cherry mx for reset
2024-02-28 see readme for changes
2024-02-28 checkboxes so people see there was progress
2024-02-29 assembly tips
2024-03-13 add controller board
2024-03-13 tick it off
2024-04-02 add ths to lib
2024-04-02 kicad 8 migration
2024-04-05 fix 9v transistor
2025-04-15 kicad 9 upgrade
2025-04-29 adjust expectations
2025-05-02 linguist override
2025-05-19 courtyards
2025-05-19 2 resistor
2025-05-19 kicad 9
2025-08-20 photo
2025-08-20 import old folder
2025-11-22 avout schematic
2025-11-22 update footprints
2025-11-22 spin image around
2025-11-22 cpu pin outs
2025-12-28 areas
2025-12-28 zerotracks
2025-12-28 link for 1chip
2025-12-28 clearance 0.125
2026-04-06 some erc errors
2026-04-06 kicad 10 update
2026-04-06 move files for 1chip merge
2026-04-06 fix lib paths
2026-04-06 probably doesn't work anymore for now
2026-04-06 1chip with markings and chips
2026-04-06 move 1chip files
2026-04-06 adjust path
2026-04-06 kciad 10 files
2026-04-06 1chip photos
2026-04-06 1snes project files
2026-04-06 export library
2026-04-06 remove wram lines
2026-04-06 remove old library
2026-04-06 2chip lib folder
2026-04-06 1chip symdir
2026-04-06 rename to folder name 2ch
2026-04-06 rename 1chip project
2026-04-06 front panel connector with pin names
2026-04-06 finish components
2026-04-06 silkscreen bottom
2026-04-06 remove images
2026-04-07 roadmap
