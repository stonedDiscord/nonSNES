File: nonSNES.kicad_pcb (KiCad board)
At the start: 2 copper layers, 188 x 158.8 mm, 55 parts, among them J1 Jack-DC, P1 CASSETTE, P2 Conn_2Rows-11Pins, P3 Conn_01x02_Male, T1 L_Coupled, U1 CPU, U12 L7805, U2 PPU1, U3 PPU2, U4 MS62256CL-10FC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

Commit message: cartridge port again
Parts:
- moved P1 47.1 mm to (151.0, 133.1)
- moved P3 1.42 mm to (104.1, 202.6)
Routing:
- net Net-(P3-Pin_2): track 20.3 -> 4.17 mm
Other:
- outline, holes or cut-outs redrawn
