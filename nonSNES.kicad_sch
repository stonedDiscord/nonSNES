File: nonSNES.kicad_sch (KiCad schematic)
At the start: 311 parts, among them J1 Jack-DC, P1 CASSETTE, P2 Conn_2Rows-11Pins, P3 Conn_01x02_Pin, Q10 C2412K, Q11 C2412K, Q12 C2412K, Q13 C2412K, Q14 C2412K, Q15 C2412K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

Commit message: add testpoints
Parts:
- added TP39, TP40, TP41, TP42, TP43, TP44, TP45, TP46, TP47, TP48, TP49, TP50, TP51, TP52, TP53, TP54, TP55, TP56, TP57, TP58, TP59, TP60, TP61, TP62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: TestPoint, TestPoint:TestPoint_Pad_D1.0mm, symbol Connector:TestPoint
- Q18: footprint Package_TO_SOT_SMD:SOT-23 -> Package_TO_SOT_SMD:SC-59
Connections:
- net CA11: now also TP84.1
- net CA12: now also TP83.1
- net CA13: now also TP82.1
- net CA14: now also TP81.1
- net CA15: now also TP80.1
- net CA16: now also TP79.1
- net CA17: now also TP78.1
- net CA18: now also TP77.1
- net CA19: now also TP76.1
- net CA20: now also TP75.1
- net CA21: now also TP74.1
- net CA22: now also TP73.1
- net CA23: now also TP72.1
- net CA5: now also TP88.1
- net CA6: now also TP86.1
- net CA7: now also TP85.1
- net CA8: now also TP87.1
- net VAA0: now also TP47.1
- net VAA1: now also TP48.1
- net VAA2: now also TP49.1
- net VAA3: now also TP50.1
- net VAA4: now also TP51.1
- net VAA5: now also TP52.1
- net VAA6: now also TP53.1
- net VAA7: now also TP54.1
- net VDA0: now also TP55.1
- net VDA1: now also TP56.1
- net VDA2: now also TP57.1
- net VDA3: now also TP58.1
- net VDA4: now also TP59.1
- net VDA5: now also TP60.1
- net VDA6: now also TP61.1
- net VDA7: now also TP62.1
- net VDB0: now also TP39.1
- net VDB1: now also TP40.1
- net VDB2: now also TP41.1
- net VDB3: now also TP42.1
- net VDB4: now also TP43.1
- net VDB5: now also TP44.1
- net VDB6: now also TP45.1
- net VDB7: now also TP46.1
- net /CPURD: now also TP90.1
- net /CPUWR: now also TP89.1
- net at U13.17 (P5RD): now also TP71.1
- net at U13.18 (P57): now also TP63.1
- net at U13.19 (P56): now also TP64.1
- net at U13.20 (P55): now also TP65.1
- net at U13.21 (P54): now also TP66.1
- net at U13.22 (P53): now also TP67.1
- net at U13.23 (P52): now also TP68.1
- net at U13.24 (P51): now also TP69.1
- net at U13.25 (P50): now also TP70.1
- no-connect marks 75 -> 66

Commit message: these resistors are 10 ohms not 100
Parts:
- R89, R90, R91: value 100 -> 10
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100" (at 44.45 59.69 90)
+    (property "Value" "10" (at 44.45 59.69 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100" (at 133.35 57.15 90)
+    (property "Value" "10" (at 133.35 57.15 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100" (at 133.35 59.69 90)
+    (property "Value" "10" (at 133.35 59.69 90)
       (effects (font (size 1.27 1.27)))
     )
