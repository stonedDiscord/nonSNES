File: nonSNES.kicad_sch (KiCad schematic)
At the start: 53 parts, among them J1 Jack-DC, P1 CASSETTE, P2 Conn_2Rows-11Pins, P3 Conn_01x02_Male, T1 L_Coupled, U1 CPU, U12 L7805, U2 PPU1, U3 PPU2, U4 MS62256CL-10FC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

Commit message: add cic and wram to board
Parts:
- added U6: WRAM, Package_SO:TSSOP-64_6.1x17mm_P0.5mm, symbol SNES_Library:WRAM
- added U7: ~, Package_SO:SSOP-18_4.4x6.5mm_P0.65mm, symbol SNES_Library:CIC
- P1: footprint Connector_DIN:DIN41612_R_2x32_Male_Vertical_THT -> SNES_Library:CASSETTE
Connections:
- net GND: now also U6.17 (GND), U6.33 (GND), U6.48 (GND), U6.64 (GND)
- net VCC: now also U6.1 (VCC), U6.16 (VCC), U6.32 (VCC), U6.49 (VCC)
- net D5: now reaches U3.10 (D5)
- net D5: now also P1.51 (D5), U1.65 (D5), U2.16 (D5), U6.3 (D5)
- net D4: now reaches U3.11 (D4)
- net D4: now also P1.50 (D4), U1.64 (D4), U2.17 (D4), U6.2 (D4)
- net D3: now reaches U3.12 (D3)
- net D3: now also P1.22 (D3), U1.63 (D3), U2.18 (D3), U6.63 (D3)
- net D2: now reaches U3.13 (D2)
- net D2: now also P1.21 (D2), U1.62 (D2), U2.19 (D2), U6.62 (D2)
- net D1: now reaches U3.14 (D1)
- net D1: now also P1.20 (D1), U1.61 (D1), U2.20 (D1), U6.61 (D1)
- net D0: now reaches U3.15 (D0)
- net D0: now also P1.19 (D0), U1.60 (D0), U2.21 (D0), U6.60 (D0)
- net D7: now reaches U3.8 (D7)
- net D7: now also P1.53 (D7), U1.67 (D7), U2.14 (D7), U6.5 (D7)
- net D6: now reaches U3.9 (D6)
- net D6: now also P1.52 (D6), U1.66 (D6), U2.15 (D6), U6.4 (D6)
- net CA7: now reaches P1.10 (A7)
- net CA7: now also U1.100 (A7), U6.39 (A7)
- net CA6: now reaches P1.11 (A6)
- net CA6: now also U1.99 (A6), U6.37 (A6)
- net CA5: now reaches P1.12 (A5)
- net CA5: now also U1.98 (A5), U6.35 (A5)
- net CA4: now reaches P1.13 (A4)
- net CA4: now also U1.97 (A4), U6.31 (A4)
- net CA3: now reaches P1.14 (A3)
- net CA3: now also U1.96 (A3), U6.29 (A3)
- net CA2: now reaches P1.15 (A2)
- net CA2: now also U1.95 (A2), U6.27 (A2)
- net CA1: now reaches P1.16 (A1)
- net CA1: now also U1.94 (A1), U6.25 (A1)
- net CA0: now reaches P1.17 (A0)
- net CA0: now also U1.93 (A0), U6.23 (A0)
- net CA12: now reaches P1.37 (A12)
- net CA12: now also U1.6 (A12), U6.30 (A12)
- net CA13: now reaches P1.38 (A13)
- net CA13: now also U1.7 (A13), U6.34 (A13)
- net CA14: now reaches P1.39 (A14)
- net CA14: now also U1.8 (A14), U6.36 (A14)
- net CA15: now reaches P1.40 (A15)
- net CA15: now also U1.9 (A15), U6.38 (A15)
- net CA16: now reaches P1.41 (A16)
- net CA16: now also U1.10 (A16), U6.40 (A16)
- net CA17: now reaches P1.42 (A17)
- net CA17: now also U1.11 (A17)
- net CA18: now reaches P1.43 (A18)
- net CA18: now also U1.12 (A18)
- net CA19: now reaches P1.44 (A19)
- net CA19: now also U1.13 (A19)
- net CA20: now reaches P1.45 (A20)
- net CA20: now also U1.14 (A20)
- net CA21: now reaches P1.46 (A21)
- net CA21: now also U1.15 (A21)
- net CA22: now reaches P1.47 (A22)
- net CA22: now also U1.16 (A22)
- net CA23: now reaches P1.48 (A23)
- net CA23: now also U1.17 (A23)
- net CA11: now reaches P1.6 (A11)
- net CA11: now also U1.5 (A11), U6.28 (A11)
- net CA10: now reaches P1.7 (A10)
- net CA10: now also U1.4 (A10), U6.26 (A10)
- net CA9: now reaches P1.8 (A9)
- net CA9: now also U1.3 (A9), U6.24 (A9)
- net CA8: now reaches P1.9 (A8)
- net CA8: now also U1.2 (A8), U6.41 (A8)

Commit message: rename cic
Parts:
- U8: renamed from U7; value ~ -> CIC
Connections:
- net GND: now also U8.9 (GND)
- net VCC: now also U8.18 (VCC)
Changed lines of the file:
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@@
+    )
+  )
+  (symbol (lib_id "power:GND") (at 56.515 394.97 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR016" (at 56.515 401.32 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 56.515 400.05 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 56.515 394.97 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 56.515 394.97 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "#PWR016") (unit 1)
+        )
+      )
     )
   )
@@
     )
   )
+  (symbol (lib_id "power:VCC") (at 73.025 374.65 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR017" (at 73.025 378.46 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "VCC" (at 73.025 370.84 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 73.025 374.65 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 73.025 374.65 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "#PWR017") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:L_Coupled_1324") (at 501.65 31.75 180) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
   (symbol (lib_id "SNES_Library:CIC") (at 65.405 383.54 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "U7" (at 64.77 370.84 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "~" (at 60.325 369.57 0)
+    (property "Reference" "U8" (at 64.77 370.84 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "CIC" (at 60.325 369.57 0)
       (effects (font (size 1.27 1.27)))
     )
@@
       (project "nonSNES"
         (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
-          (reference "U7") (unit 1)
-        )
-      )
+          (reference "U8") (unit 1)
+        )
+      )
