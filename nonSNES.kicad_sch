File: nonSNES.kicad_sch (KiCad schematic)
At the start: 55 parts, among them J1 Jack-DC, P1 CASSETTE, P2 Conn_2Rows-11Pins, P3 Conn_01x02_Male, T1 L_Coupled, U1 CPU, U12 L7805, U2 PPU1, U3 PPU2, U4 MS62256CL-10FC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

Commit message: wire cic and reset sw
Parts:
- added C29, C85: 0.1u, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Polarized
- added C62: 2.2u, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Polarized
- added SW1: RESET SW, Button_Switch_THT:SW_MEC_5GTH9, symbol Switch:SW_Push
Connections:
- net GND: now also C85.2
- net VCC: now also U8.4 (P03), C29.1, C62.1, C85.1, SW1.2
- net at U8.3 (P02): now also C62.2
- net at U8.8 (RES): now also C29.2, SW1.1
Changed lines of the file:
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@@
   (junction (at 66.04 54.61) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 73.025 366.395) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 38.1 57.15) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 260.35 152.4) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 40.64 366.395) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 97.79 49.53) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 260.35 121.92) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 46.99 366.395) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 222.885 251.46) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 185.42 227.33) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 40.64 392.43) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 102.87 76.2) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 381 29.21) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 43.18 366.395) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 260.35 149.86) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 40.64 392.43) (xy 56.515 392.43))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 195.58 189.23) (xy 195.58 191.77))
     (stroke (width 0) (type default) (color 0 255 251 1))
   )
+  (wire (pts (xy 56.515 382.27) (xy 43.18 382.27))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 454.66 36.83) (xy 450.85 36.83))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 56.515 379.73) (xy 46.99 379.73))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 267.97 210.82) (xy 267.97 213.36))
     (stroke (width 0) (type default) (color 0 255 251 1))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 46.99 366.395) (xy 43.18 366.395))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 221.615 231.14) (xy 221.615 233.68))
     (stroke (width 0) (type default) (color 155 73 0 1))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 73.025 366.395) (xy 78.105 366.395))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 139.7 147.32) (xy 139.7 149.86))
     (stroke (width 0) (type default) (color 255 126 0 1))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 73.025 366.395) (xy 46.99 366.395))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 109.22 309.88) (xy 114.935 309.88))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 46.99 379.73) (xy 46.99 377.825))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 118.745 317.5) (xy 118.745 318.135))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default) (color 155 73 0 1))
   )
+  (wire (pts (xy 31.75 366.395) (xy 31.75 382.27))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 146.05 209.55) (xy 146.05 212.09))
     (stroke (width 0) (type default) (color 255 126 0 1))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 40.64 366.395) (xy 31.75 366.395))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 30.48 309.245) (xy 30.48 306.705))
     (stroke (width 0) (type default) (color 255 134 0 1))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 43.18 366.395) (xy 40.64 366.395))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 30.48 43.18) (xy 30.48 52.07))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 43.18 382.27) (xy 43.18 366.395))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 267.97 193.04) (xy 267.97 195.58))
     (stroke (width 0) (type default) (color 0 255 251 1))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 46.99 366.395) (xy 46.99 370.205))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 33.02 314.325) (xy 38.735 314.325))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default) (color 0 255 251 1))
   )
+  (wire (pts (xy 40.64 366.395) (xy 40.64 384.81))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 38.1 57.15) (xy 26.67 57.15))
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 73.025 366.395) (xy 73.025 374.65))
+    (stroke (width 0) (type default))
+  )
   (bus (pts (xy 71.12 325.12) (xy 71.12 327.025))
     (stroke (width 0) (type default) (color 155 73 0 1))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 31.75 392.43) (xy 40.64 392.43))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 73.66 322.58) (xy 83.82 322.58))
     (stroke (width 0) (type default))
@@
     )
   )
+  (symbol (lib_id "Device:C_Polarized") (at 40.64 388.62 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C29" (at 44.45 387.096 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "0.1u" (at 44.45 389.636 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric" (at 41.6052 392.43 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 40.64 388.62 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "C29") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:C") (at 513.08 33.02 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "Device:C_Polarized") (at 46.99 374.015 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C62" (at 50.8 372.491 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "2.2u" (at 50.8 375.031 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric" (at 47.9552 377.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 46.99 374.015 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "C62") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GNDPWR") (at 393.7 44.45 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "Device:C_Polarized") (at 78.105 370.205 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C85" (at 81.28 368.681 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "0.1u" (at 81.28 371.221 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric" (at 79.0702 374.015 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 78.105 370.205 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "C85") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GNDPWR") (at 266.7 124.46 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
-  (symbol (lib_id "power:VCC") (at 73.025 374.65 0) (unit 1)
+  (symbol (lib_id "power:VCC") (at 73.025 366.395 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR017" (at 73.025 378.46 0)
+    (property "Reference" "#PWR017" (at 73.025 370.205 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "VCC" (at 73.025 370.84 0)
+    (property "Value" "VCC" (at 73.025 362.585 0)
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 73.025 374.65 0)
+    (property "Footprint" "" (at 73.025 366.395 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 73.025 374.65 0)
+    (property "Datasheet" "" (at 73.025 366.395 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
+  (symbol (lib_id "Switch:SW_Push") (at 31.75 387.35 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "SW1" (at 33.02 386.715 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "RESET SW" (at 33.02 389.255 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "Button_Switch_THT:SW_MEC_5GTH9" (at 26.67 387.35 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 26.67 387.35 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "SW1") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:C_Polarized") (at 60.96 72.39 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:GND") (at 78.105 374.015 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR018" (at 78.105 380.365 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 78.105 379.095 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 78.105 374.015 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 78.105 374.015 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "#PWR018") (unit 1)
+        )
+      )

Commit message: pad and cap
Parts:
- added C67: 1000u, Capacitor_THT:CP_Radial_D16.0mm_P7.50mm, symbol Device:C_Polarized
- P2: footprint Connector_JST:JST_ZE_B11B-ZESK-D_1x11_P1.50mm_Vertical -> SNES_Library:JST_ZE_Controllers
Changed lines of the file:
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@@
+    )
+  )
+  (symbol (lib_id "Device:C_Polarized") (at 417.195 59.69 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C67" (at 420.37 58.166 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "1000u" (at 420.37 60.706 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Capacitor_THT:CP_Radial_D16.0mm_P7.50mm" (at 418.1602 63.5 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 417.195 59.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "C67") (unit 1)
+        )
+      )
     )
   )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Connector_JST:JST_ZE_B11B-ZESK-D_1x11_P1.50mm_Vertical" (at 87.63 54.61 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "SNES_Library:JST_ZE_Controllers" (at 87.63 54.61 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: avout and rfmod
Parts:
- added P4: ~, SNES_Library:AVOut, symbol SNES_Library:AVOUT
- added U7: ~, SNES_Library:RFModulator, symbol SNES_Library:RFMODULATOR
Connections:
- net GND: now also P4.5 (GND), P4.6 (GND), U7.4 (GND)
Other:
- moved on the sheet: C67
Changed lines of the file:
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@@
     (stroke (width 0) (type default) (color 0 255 251 1))
   )
+  (wire (pts (xy 494.665 128.27) (xy 497.84 128.27))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 127 231.14) (xy 137.16 231.14))
     (stroke (width 0) (type default))
@@
     )
   )
+  (symbol (lib_id "SNES_Library:RFMODULATOR") (at 506.73 124.46 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "U7" (at 514.35 125.095 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "~" (at 501.65 120.65 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "SNES_Library:RFModulator" (at 501.65 120.65 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 501.65 120.65 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (pin "3")
+    (pin "4")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "U7") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:C_Polarized") (at 40.64 388.62 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
-  (symbol (lib_id "Device:C_Polarized") (at 417.195 59.69 0) (unit 1)
+  (symbol (lib_id "Device:C_Polarized") (at 342.265 38.735 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C67" (at 420.37 58.166 0)
+    (property "Reference" "C67" (at 345.44 37.211 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "1000u" (at 420.37 60.706 0)
+    (property "Value" "1000u" (at 345.44 39.751 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_THT:CP_Radial_D16.0mm_P7.50mm" (at 418.1602 63.5 0)
+    (property "Footprint" "Capacitor_THT:CP_Radial_D16.0mm_P7.50mm" (at 343.2302 42.545 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 417.195 59.69 0)
+    (property "Datasheet" "~" (at 342.265 38.735 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 446.405 78.74 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR021" (at 452.755 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 450.215 79.375 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "" (at 446.405 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 446.405 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "#PWR021") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:C") (at 483.87 33.02 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 423.545 78.74 270) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR020" (at 417.195 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 419.735 79.375 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "" (at 423.545 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 423.545 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "#PWR020") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 260.35 152.4 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "SNES_Library:AVOUT") (at 434.975 73.66 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "P4" (at 434.975 71.12 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "~" (at 423.545 73.66 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "SNES_Library:AVOut" (at 423.545 73.66 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 423.545 73.66 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "10")
+    (pin "11")
+    (pin "12")
+    (pin "2")
+    (pin "3")
+    (pin "4")
+    (pin "5")
+    (pin "6")
+    (pin "7")
+    (pin "8")
+    (pin "9")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "P4") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 67.31 347.345 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:GND") (at 494.665 128.27 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR019" (at 494.665 134.62 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 494.665 133.35 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 494.665 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 494.665 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "nonSNES"
+        (path "/d1480d56-b791-43e1-bd4c-b0c74bb0533d"
+          (reference "#PWR019") (unit 1)
+        )
+      )
